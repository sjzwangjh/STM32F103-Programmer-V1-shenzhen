# Keil uVision project STM32F103VET6_Programmer.uvprojx, settings and files
target STM32F103_HID_Programmer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x0800C000,0x00074000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,__NO_EMBEDDED_ASM
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE\LED;..\HARDWARE\LCD12864;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\EEPROM;..\HARDWARE\FLASH;..\HARDWARE\FAT32;..\HARDWARE\SDCARD;..\HARDWARE\IICSoftware;..\HARDWARE\MCP4017;..\HARDWARE\POWER;..\HARDWARE\DUT_BUS;..\USB\LIB;..\USB\CONFIG;..\PROGRAMMER;..\HANDLER;..\USER
  memory RVCT4: ROM 0x800c000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c Stk500Protocol.c debugBin.c sdCardUser.c offLineRecorder.c offLinePgmer.c avrDude指令集.md
  group SYSTEM
    ../SYSTEM/sys/: startup_stm32f10x_hd.s sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/LCD12864/: FontGB2312.c Lcd12864.c
    ../HARDWARE/IICSoftware/: iicSoftware.c
    ../HARDWARE/MCP4017/: MCP4017_VDD.c MCP4017_VPP.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/DUT_BUS/: dutBus.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/SDCARD/: sdcard.c
    ../HARDWARE/FAT32/: diskio.c ff.c
  group USB_CORE
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_CFG
    ../USB/CONFIG/: stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c hw_USB_config.c Usb_Hid_User.c usb_cdc_user.c
  group PROGRAMMER
    ../PROGRAMMER/: isp.c hvproc.c icsp.c picDeviceConst.c avrOffLinePgm.c picOffLinePgm.c avrDeviceConst.c avrdude-avr-init.xml pic10-12-16-init.xml
  group HANDLER
    ../HANDLER/: handler.c
